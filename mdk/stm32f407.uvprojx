# Keil uVision project stm32f407.uvprojx, settings and files
target APP0 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: stm32f407_app0 +hex
  AfterMake: fromelf --bin "#L" --output "./Objects/stm32f407_app0.bin"
  AfterMake: python ../scripts/gen_magic_header.py "./Objects/stm32f407_app0.bin" 0
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,HSE_VALUE=8000000
  c include: ..\firmware\cmsis\core;..\firmware\cmsis\device;..\firmware\driver\inc;..\app;..\app\font;..\app\image;..\app\page;..\driver\aht20;..\driver\tim_delay;..\driver\esp_at;..\driver\led;..\driver\console;..\driver\st7789;..\driver\rtc;..\third_lib\FreeRTOS\include;..\third_lib\FreeRTOS\portable
  library: MicroLIB
  memory RVCT4: ROM 0x8010000 size 0x3ff00
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\Objects\stm32f407_app0.sct
  group app
    ../app/: main.c board.c app.c wifi.c weather.c ui.c workqueue.c
  group app/font
    ../app/font/: font24_maple_bold.c font32_maple_bold.c font20_maple_bold.c font16_maple.c font24_maple_semibold.c font54_maple_bold.c font54_maple_semibold.c font64_maple_extrabold.c font76_maple_extrabold.c
  group app/image
    ../app/image/: image.c icon_duoyun.c icon_leizhenyu.c icon_na.c icon_qing.c icon_wenduji.c icon_wifi.c icon_yintian.c icon_yueliang.c icon_zhongxue.c icon_zhongyu.c img_wifi.c
  group app/page
    ../app/page/: welcome_page.c error_page.c wifi_page.c main_page.c
  group driver
    ../driver/rtc/: rtc.c
    ../driver/console/: console.c
    ../driver/aht20/: aht20.c
    ../driver/st7789/: st7789.c
    ../driver/esp_at/: esp_at.c
    ../driver/tim_delay/: tim_delay.c
  group firmware/cmsis
    ../firmware/cmsis/device/: startup_stm32f40_41xxx.s system_stm32f4xx.c
  group firmware/driver
    ../firmware/driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_can.c stm32f4xx_cec.c stm32f4xx_crc.c stm32f4xx_cryp.c stm32f4xx_cryp_aes.c stm32f4xx_cryp_des.c stm32f4xx_cryp_tdes.c stm32f4xx_dac.c stm32f4xx_dbgmcu.c stm32f4xx_dcmi.c stm32f4xx_dfsdm.c stm32f4xx_dma.c stm32f4xx_dma2d.c stm32f4xx_dsi.c stm32f4xx_exti.c stm32f4xx_flash.c stm32f4xx_flash_ramfunc.c stm32f4xx_fmpi2c.c stm32f4xx_fsmc.c stm32f4xx_gpio.c stm32f4xx_hash.c stm32f4xx_hash_md5.c stm32f4xx_hash_sha1.c stm32f4xx_i2c.c stm32f4xx_iwdg.c stm32f4xx_lptim.c stm32f4xx_ltdc.c stm32f4xx_pwr.c stm32f4xx_qspi.c stm32f4xx_rcc.c stm32f4xx_rng.c stm32f4xx_rtc.c stm32f4xx_sai.c stm32f4xx_sdio.c stm32f4xx_spdifrx.c stm32f4xx_spi.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_wwdg.c
  group third_lib
    ../third_lib/freertos/: list.c queue.c tasks.c timers.c
    ../third_lib/freertos/portable/: heap_4.c port.c
target APP1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1
  cpu: as above
  output: stm32f407_app1 +hex
  AfterMake: fromelf --bin "#L" --output "./Objects/stm32f407_app1.bin"
  AfterMake: python ../scripts/gen_magic_header.py "./Objects/stm32f407_app1.bin" 1
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER,HSE_VALUE=8000000
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8050000 size 0x2ff00
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\Objects\stm32f407_app1.sct
